# Keil uVision project AolkmeSDKLIB.uvprojx, settings and files
target AolkmeSDK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AolkmeSDKLIB (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Aolkme\include;.\Aolkme\internal;.\Aolkme\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Aolkme/include
    ../AolkmeSDKProject/AOLKME/include/: Aolkme.h Aolkme_core.h Aolkme_error.h Aolkme_platform.h Aolkme_typedef.h Aolkme_version.h
    ../AolkmeSDKProject/AolkmeComponent/AolkmeEvent/include/: Aolkme_event.h Aolkme_event_types.h
    ../AolkmeSDKProject/AolkmeComponent/AolkmeLogger/: Aolkme_logger.h
  group Aolkme/internal
    ../AolkmeSDKProject/AOLKME/src/internal/: Aolkme_core_private.h
    ../AolkmeSDKProject/AolkmeComponent/AolkmeLogger/: logger_buffer.h logger_core.h logger_formatter.h
  group Aolkme/src
    ../AolkmeSDKProject/AOLKME/src/code/: Aolkme.c Aolkme_core.c Aolkme_platform.c Aolkme_verify.c
    ../AolkmeSDKProject/AolkmeComponent/AolkmeEvent/src/: Aolkme_event.c
    ../AolkmeSDKProject/AolkmeComponent/AolkmeLogger/: logger_buffer.c logger_core.c logger_formatter.c
