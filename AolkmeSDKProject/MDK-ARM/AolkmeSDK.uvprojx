# Keil uVision project AolkmeSDK.uvprojx, settings and files
target AolkmeSDK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: AolkmeSDK +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,STM32_THREAD_SAFE_STRATEGY=4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../AolkmeComponent/AolkmeOSAL/src;../AolkmeComponent/AolkmeOSAL/include;../AOLKME/include;..\AOLKME\src\code;..\AOLKME\src\internal;../AolkmeComponent/AolkmeEvent/include;../AolkmeComponent/AolkmeEvent/src;../App;..\AolkmeComponent\Aolkmemisc;..\AolkmeComponent\AolkmeLogger;..\AolkmeComponent\AolkmeOSAL_SystemMonitor
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s armlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group AOLKME/include
    ../AOLKME/include/: Aolkme.h Aolkme_core.h Aolkme_error.h Aolkme_platform.h Aolkme_typedef.h Aolkme_version.h
  group AOLKME/src
    ../AOLKME/src/code/: Aolkme_core.c Aolkme_platform.c Aolkme_verify.c
    ../AOLKME/src/internal/: Aolkme_core_private.h
  group Aolkme/Component
    ../AolkmeComponent/AolkmeOSAL/include/: Aolkme_OSAL.h
    ../AolkmeComponent/AolkmeOSAL/src/: Aolkme_OSAL.c
    ../AolkmeComponent/AolkmeEvent/include/: Aolkme_event_types.h Aolkme_event.h
    ../AolkmeComponent/AolkmeEvent/src/: Aolkme_event.c
    ../AolkmeComponent/Aolkmemisc/: Aolkme_misc.c Aolkme_misc.h
    ../AolkmeComponent/AolkmeLogger/: Aolkme_logger.h logger_buffer.c logger_buffer.h logger_core.c logger_core.h logger_formatter.c logger_formatter.h
    ../AolkmeComponent/AolkmeOSAL_SystemMonitor/: AolkmeOSAL_SysMon.h AolkmeOSAL_SysMon_freertos.c
  group App
    ../AOLKME/src/code/: Aolkme.c
    ../App/: application.c application.h
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: AolkmeSDK +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,STM32_THREAD_SAFE_STRATEGY=4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
software components: CMSIS:CORE 4.3.0
